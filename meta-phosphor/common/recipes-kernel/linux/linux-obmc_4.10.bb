KBRANCH ?= "dev-4.10"
LINUX_VERSION ?= "4.10.17"

SRCREV="37d81bcb1d8388ec3ca7989207cd8cc59c14b60f"

require linux-obmc.inc
